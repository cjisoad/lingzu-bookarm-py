Commit message: 完成视觉书本抓取效果

File: resources/urdf/el_a3.urdf (robot description, URDF)
Before this commit: robot EL-A3, 10 links, 9 joints
Joints:
- joint L1_joint: limit lower=-2.79253 upper=2.79253 effort=14 velocity=33 -> lower=-4.71239 upper=4.71239 effort=14 velocity=33
